# Keil uVision project BareBonesCM0.uvprojx, settings and files
target DebugOnly (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: BareBonesCM0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Src
    ./: blinkySEVDelay.s blinkySEV.s
target BlinkySEV (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: BareBonesCM0 +hex
  AfterMake: fromelf.exe -cvf Objects/BareBonesCM0.axf --vhx --32x1 -o code.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x200
  memory RVCT9: RAM 0x200 size 0x400
target BlinkySevDelay (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: BareBonesCM0 +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x200
  memory RVCT9: RAM 0x200 size 0x400
